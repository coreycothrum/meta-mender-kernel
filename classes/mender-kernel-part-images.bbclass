IMAGE_TYPEDEP_biosimg += "kernelimg"
IMAGE_TYPEDEP_gptimg  += "kernelimg"
IMAGE_TYPEDEP_sdimg   += "kernelimg"
IMAGE_TYPEDEP_uefiimg += "kernelimg"
