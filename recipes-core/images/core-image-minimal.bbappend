require conf/include/mender-kernel-image.inc
