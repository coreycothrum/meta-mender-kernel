require mender-kernel-linux-yocto.inc
